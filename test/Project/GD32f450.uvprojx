# Keil uVision project GD32f450.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.5
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32f450 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F450
  c include: ..\User;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\GD32F4xx_standard_peripheral\Include;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\App;..\Hardware;..\Hardware\cs1237;..\Hardware\dac;..\Hardware\hlw8112;..\Hardware\YT8512C;..\LwIP\src\include;..\LwIP\port\GD32F4xx;..\LwIP\port\GD32F4xx\FreeRTOS;..\LwIP\port\GD32F4xx\arch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c usart.c
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_usart.c gd32f4xx_dac.c gd32f4xx_enet.c gd32f4xx_syscfg.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Doc
    ../Doc/: readme.txt
  group Hardware
    ../Hardware/cs1237/: bsp_cs1237.c
    ../Hardware/dac/: bsp_dac.c
    ../Hardware/hlw8112/: bsp_hlw8112.c
    ../Hardware/YT8512C/: bsp_yt8512c.c
  group App
    ../App/: app_cs1237.c app_hlw8112.c
  group FreeRTOS
    ../FreeRTOS/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group LwIP_Core
    ../LwIP/src/core/: init.c def.c dns.c inet_chksum.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c altcp.c altcp_alloc.c altcp_tcp.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c acd.c
    ../LwIP/src/netif/: ethernet.c
  group LwIP_Api
    ../LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP_Port
    ../LwIP/port/GD32F4xx/FreeRTOS/: sys_arch.c ethernetif.c
