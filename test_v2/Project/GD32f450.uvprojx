# Keil uVision project GD32f450.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.5
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32f450 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F450
  c include: ..\User;..\User\lwip_port;..\User\lwip_app;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\GD32F4xx_standard_peripheral\Include;..\LwIP\src\include;..\LwIP\src\include\ipv4;..\LwIP\port;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c usart.c bsp_dac.c bsp_lan8720.c bsp_lan8702.c bsp_cs1237.c bsp_hlw8112.c bsp_cs1238.c app_dyno_global.c app_dyno_control.c app_protocol_binary.c app_protocol_modbus.c bsp_sdram.c bsp_timer.c bsp_jsy_mk1031.c
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_usart.c gd32f4xx_dac.c gd32f4xx_enet.c gd32f4xx_syscfg.c gd32f4xx_exmc.c gd32f4xx_timer.c gd32f4xx_exti.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Doc
    ../Doc/: readme.txt
  group LwIP-Core
    ../LwIP/src/core/: init.c dhcp.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group LwIP-IPv4
    ../LwIP/src/core/ipv4/: icmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LwIP-Netif
    ../LwIP/src/netif/: etharp.c
  group LwIP-Port
    ../User/lwip_port/: ethernetif.c
  group LwIP-App
    ../User/lwip_app/: lwip_demo.c tcp_client_app.c tcp_server_demo.c
  group FreeRTOS/Core
    ../FreeRTOS/source/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c
  group FreeRTOS/Port
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
